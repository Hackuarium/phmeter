File: pcb/main/pHMeter.kicad_pcb (KiCad board)
At the start: 2 copper layers, 100 x 87 mm, 148 parts, among them J1 Conn_02x03_Odd_Even, J2 Conn_Coaxial_Power, J3 Conn_Coaxial_Power, J4 AudioJack3_SwitchTR, J5 RJ12, J6 AudioJack3_SwitchTR, J7 SJ, J8 SJ, Q1 ZXMS6004, Q2 ZXMS6004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

Commit message: Update PCB connection, run ERC and update pinMapping.md
Routing:
- net TX: track 41.3 -> 184.9 mm, vias 2 -> 4
- net D7: track 86.9 -> 117.3 mm
- net VBAT: track 9.94 -> 36.1 mm, vias 0 -> 2
- net GND: track 35.4 -> 42.4 mm, vias 16 -> 17
- net Net-(D10-Pad2): track 0.00 -> 3.04 mm
- net 3.3V: track 356.9 -> 357.5 mm
