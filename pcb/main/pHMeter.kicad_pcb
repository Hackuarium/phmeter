# Repository Hackuarium/phmeter

File README.md:

# phmeter

Open source design of a battery powered pH meter

- LCD screen (2 lines) (8 pins).
- Rotary push button (3 pins).
- RJ-12 connector to a master.
- ATMEGA32U4.
- 64 Mbit memory ISP (available version).
- 2 pumps (only use in 12 V power supply mode).
- 4 I/O 12 V.
- Battery charger.
- pH measurement.
- Elecrtical conductivity measurement.
- 2 probes temperature sensors.

## BOM

[iBOM](/pcb/main/bom/README.md)

## Cloning the project

In order to clone it use:

git clone --recurse-submodules [https://github.com/Hackuarium/phmeter](https://github.com/Hackuarium/phmeter)

To update the submodules:

git submodule update --recursive --remote

Last update: 04/08/2021

## To Do

- Check I2C communication. (created branch _i2c_communication_ 04212022)
- Equation for pH. (in process)
- Equation for EC. (in process)

## KiCad design pcb/main/pHMeter.kicad_pcb

File pcb/README.md (part):

# PHMeter

PH Meter and Conductometer that can work independently

## Tips

### Configure permission for USBTinyISP

- Check the ID for USBTinyISP:

´´´
$ lsusb
´´´

´´´
Bus 002 Device 001: ID 1d6b:0003 Linux Foundation 3.0 root hub
Bus 001 Device 005: ID 8087:0a2b Intel Corp.
Bus 001 Device 006: ID 047f:0115 Plantronics, Inc. Voyager Legend
Bus 001 Device 003: ID 046d:c31c Logitech, Inc. Keyboard K120
Bus 001 Device 002: ID 046d:c011 Logitech, Inc. Optical MouseMan
Bus 001 Device 007: ID 1781:0c9f Multiple Vendors USBtiny
Bus 001 Device 001: ID 1d6b:0002 Linux Foundation 2.0 root hub
´´´

Show _Device 007_ permissions:

´´´
$ ls -al /dev/bus/usb/001/007
´´´

´´´
crw-rw---- 1 root root 189, 6 Okt 2 09:45 /dev/bus/usb/001/007
´´´

Change permissions:

´´´
$ sudo chmod 666 /dev/bus/usb/001/007
´´´

Check the new permissions:

´´´
$ ls -al /dev/bus/usb/001/007
´´´

´´´
crw-rw-rw- 1 root root 189, 6 Okt 2 09:45 /dev/bus/usb/001/007
´´´

## Pin Configuration - PHMeter V 1.1.2-b (PCB version 1.1.2-b)

Based on: [ATMEGA32U4 - Arduino Lilypad USB/Leonardo](https://docs.arduino.cc/hacking/hardware/PinMapping32u4)

| µC Pin | Pin Port | Digital Port | Analog Port | Alternate Functions                           | Arduino Functions | PHMeter Functions | Description                                                                                                                                                                                                                                                     |
| ------ | -------- | ------------ | ----------- | --------------------------------------------- | ----------------- | ----------------- | --------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------- |
| 1      | PE6      | 7            |             | INT6 <br /> /AIN0                             |                   | ROT_PUSH          | - **Rotary push button**. <br /> - External Interrupt 6 Input. <br /> - Analog Comparator Positive Input.                                                                                                                                                       |
| 2      | UVcc     |              |             |                                               | UVCC              | UVCC              | USB Pads Internal Regulator Input supply voltage.                                                                                                                                                                                                               |
| 3      | D-       |              |             |                                               | RD-               | D-                | USB Full speed / Low Speed Negative Data Upstream Port. Should be connected to the USB D- connector pin with a serial 22 Ohm resistor.                                                                                                                          |
| 4      | D+       |              |             |                                               | RD+               | D+                | USB Full speed / Low Speed Positive Data Upstream Port. Should be connected to the USB D+ connector pin with a serial 22 Ohm resistor.                                                                                                                          |
| 5      | UGND     |              |             |                                               | UGND              | GND               | USB Pads Ground.                                                                                                                                                                                                                                                |
| 6      | UCap     |              |             |                                               | UCAP              | UCAP              | USB Pads Internal Regulator Output supply voltage. Should be connected to an external capacitor (1μF).                                                                                                                                                          |
| 7      | VBus     |              |             |                                               | VUSB              | VUSB              | USB VBUS monitor input.                                                                                                                                                                                                                                         |
| 8      | PB0      |              |             | /SS <br /> PCINT0                             | RXLED             | ONE_WIRE_1        | - **Ext. OneWire 1**. <br /> - SPI Slave Select input. <br /> - Pin Change Interrupt 0.                                                                                                                                                                         |
| 9      | PB1      |              |             | SCK <br /> PCINT1                             | SCK               | SCK               | - **SCK for external Flash Memory.** <br /> - SPI Bus Serial Clock. <br /> - Pin Change Interrupt 1.                                                                                                                                                            |
| 10     | PB2      |              |             | PDI <br /> MOSI <br /> PCINT2                 | MOSI              | MOSI              | - **MOSI for external Flash Memory.** <br /> - Programming Data Input. <br /> - SPI Bus Master Output/Slave Input. <br /> - Pin Change Interrupt 2.                                                                                                             |
| 11     | PB3      |              |             | PDO <br /> MISO <br /> PCINT3                 | MISO              | MISO              | - **MISO for external Flash Memory.** <br /> - Programming Data Output. <br /> - SPI Bus Master Input/Slave Output. <br /> - Pin Change Interrupt 3.                                                                                                            |
| 12     | PB7      | 11           |             | OC0A <br /> OC1C <br /> PCINT7 <br /> /RTS    | PWM               | OUT_1             | - **Pin for Input/Ouput 1 (PWM alkaline)**. <br /> - Output Compare and PWM Output A for Timer/Counter0. <br /> - Output Compare and PWM Output C for Timer/Counter1. <br /> - Pin Change Interrupt 7. <br /> - UART flow control RTS signal.                   |
| 13     | /RESET   |              |             |                                               | /RESET            | /RESET            | Reset input.                                                                                                                                                                                                                                                    |
| 14     | Vcc      |              |             |                                               | VCC               | VCC               |                                                                                                                                                                                                                                                                 |
| 15     | GND      |              |             |                                               | GND               | GND               |                                                                                                                                                                                                                                                                 |
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
Board: 2 copper layers, 100.0 x 87.0 mm, 150 parts (4 on the bottom side), 100 nets.

Parts:
C1, C3, C7, C15, C16, C17, C22, C26, C28, C33: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C8, C12, C34: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C10, C30, C32: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 1.5n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C11, C19, C20, C21, C23, C27, C29, C31: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C9, C24, C25: 22u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C13, C14: 18p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C18: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C35: 20p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C36, C37: 100u; CP_Elec_8x10
D1, D2: 1N4148W; D_SOD-123
D3, D4, D5, D14: MBR0520LT1G; D_SOD-123
D6: 1N5819; D_SOD-123
D7, D8, D15, D16: GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D9, D11, D19: YELLOW; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D12, D13, D17, D18: BLUE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
DS1: WC1602A
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_02x03_Odd_Even; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J2, J3: Conn_Coaxial_Power; BNC_TEConnectivity_1478204_Vertical
J4, J6: AudioJack3_SwitchTR; Jack_3.5mm_Ledino_KB3SPRS_Horizontal
J5: RJ12; E5566-Q0LK22-L
J7, J8: SJ; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP1, JP2: JP1E; PinHeader_1x02_P2.54mm_Vertical
JP3: acidic; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
JP4: alkaline; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
JP5: Bat; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
JP6: IO3; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
JP7: IO4; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
L2: 3.9u; L_Taiyo-Yuden_NR-24xx_HandSoldering
Q1, Q2, Q4, Q5: ZXMS6004; SOT-23
Q3: DMP1045; SOT-23
R1: 820; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4, R13, R16, R25, R26, R27, R28, R29, R30, R34, R36, R37, R39, R41, R47, R48: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5, R7, R8, R9, R10, R12: 36k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11: 56.2k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R14, R15: 22; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R17: 51k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18: 2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R19, R20, R23, R24, R40, R42, R43, R44, R49, R55: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R21, R51: 4.7k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R22, R32, R33, R53: 100; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R31: 0; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R35, R38, R45: 1M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R46: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RV1: 10k; Potentiometer_Bourns_3339P_Vertical_HandSoldering
SJ1: JUMPER-PAD-2-NC_BY_TRACE; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
SW1: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
U1, U2: TLV6004PW; TSSOP-14_4.4x5mm_P0.65mm
U3: ATMEGA32U4-AU; TQFP-44_10x10mm_P0.8mm
U4: MCP1703A; SOT-23
U5: AP63203WU-7; TSOT-23-6
U6: HX711; SOIC-16_3.9x9.9mm_P1.27mm
U7: SST26VF064B; SOIJ-8_5.3x5.3mm_P1.27mm
U8: CD4060BM
U9: MCP73811T; SOT-23-5
U10: LM2660M
X1: MINI-USB-SCHIELD-32005-201; USB_Mini-B_Lumberg_2486_01_Horizontal
Y1: Crystal; Crystal_SMD_0603-2Pin_6.0x3.5mm_HandSoldering
logoHackuarium: logoHackuarium
logoHackuarium#2: logoHackuarium

Connections:
3.3V: C1.1, C8.1, C10.1, C12.1, C17.1, C24.2, C25.2, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, JP1.1, L2.2, R3.2, R22.2, R23.2, R24.1, R25.1, R28.1, R34.1, R40.1, R41.1, R42.2, R53.2, R55.2, U1.4, U2.4, U3.2, U3.14, U3.24, U3.34, U3.44, U5.1, U6.1, U6.3, U6.16, U7.3, U7.7, U7.8, U8.16, U10.8
12V: C20.1, J5.1, JP2.1, JP3.1, JP4.1, JP6.1, JP7.1, R16.1, U4.3
-3V3: C2.1, C4.2, C32.2, C34.1, C37.2, U2.11, U8.8, U8.12, U10.5
A0: U3.36, U6.12
A1: U3.37, U6.11
A2: Q4.1, R47.1, U3.38
A3: Q5.1, R48.1, U3.39
A4: C33.1, R38.2, R45.1, U3.40
A5: C35.1, D6.1, R12.1, U3.41
A6: DS1.4, U3.25
AREF: C16.1, U3.42
B+: C9.1, R11.1, R13.2, U6.10
B-: R13.1, U1.6, U1.7, U6.9
CT1: J2.1, R18.2, U2.1
CT2: J2.2, R1.2, U2.6
D5: DS1.14, U3.31
D6: DS1.6, U3.27
D7: SW1.S1, U3.1
D8: DS1.11, U3.28
D9: DS1.12, U3.29
D10: DS1.13, U3.30
D11: Q1.1, R26.1, U3.12
D12: Q2.1, R27.1, U3.26
D13: DS1.2, R20.1, R31.1, R32.1, U3.32
GND: C1.2, C2.2, C3.2, C4.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C23.2, C24.1, C25.1, C26.2, C27.2, C30.2, C31.2, C32.1, C33.2, C34.2, C35.2, C37.1, D6.2, D7.1, D8.1, D12.1, D13.1, D15.1, D16.1, D17.1, D18.1, DS1.1, DS1.5, DS1.16, J1.6, J4.R, J5.4, J5.6, J6.R, J7.2, J8.1, JP1.2, JP2.2, JP5.2, Q1.2, Q2.2, Q4.2, Q5.2, R4.2, R33.2, R36.1, R37.1, R45.2, R46.2, SJ1.1, SW1.C, SW1.S2, U1.11, U2.3, U2.5, U2.10, U3.5, U3.15, U3.23, U3.35, U3.43, U4.1, U5.4, U6.14, U7.4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
HWB: R36.2, U3.33
LGND: C28.2, C29.2, SJ1.2, U6.4, U6.5
MISO: J1.1, U3.11, U7.2
MOSI: J1.4, R42.1, U3.10, U7.5
unnamed: C3.1, R3.1, R4.1, U1.3, U1.5
unnamed: C5.1, U8.9
unnamed: C5.2, R2.2, R6.2
unnamed: C6.1, C7.1, D5.2, U4.2
unnamed: C13.1, R35.1, U3.17, Y1.1
unnamed: C14.1, R35.2, U3.16, Y1.2
unnamed: C18.1, U3.6
unnamed: C22.1, L2.1, U5.5
unnamed: C22.2, U5.6
unnamed: C23.1, JP5.1, Q3.3, R38.1, U9.3
unnamed: C36.1, U10.2
unnamed: C36.2, U10.4
unnamed: D1.1, D2.2, U2.8
unnamed: D1.2, R7.1, R9.2
unnamed: D2.1, R8.1, U2.13
unnamed: D3.2, J1.2
unnamed: D7.2, R16.2
unnamed: D8.2, R20.2
unnamed: D9.1, J6.S, R21.2, R22.1
unnamed: D9.2, R23.1
unnamed: D11.2, R24.2
unnamed: D12.2, R27.2
unnamed: D13.2, R26.2
unnamed: D15.2, R39.2
unnamed: D16.2, R40.2
unnamed: D17.2, R47.2
unnamed: D18.2, R48.2
unnamed: D19.1, J4.S, R51.2, R53.1
unnamed: D19.2, R55.1
unnamed: DS1.3, RV1.2
unnamed: DS1.15, R31.2
unnamed: J3.1, U1.10
unnamed: J3.2, U1.1, U1.2
unnamed: J4.T, R49.2, R51.1
unnamed: J6.T, R19.2, R21.1
unnamed: J8.2, R41.2, U6.15
unnamed: JP3.2, Q2.3
unnamed: JP4.2, Q1.3
unnamed: JP6.2, Q4.3
unnamed: JP7.2, Q5.3
unnamed: R1.1, R5.2, U2.7
unnamed: R2.1, U8.11
unnamed: R5.1, R7.2, R8.2, U2.9
unnamed: R6.1, U8.10
unnamed: R10.1, R12.2, U2.14
unnamed: R9.1, R10.2, U2.12
unnamed: R11.2, U1.8, U1.9
unnamed: R14.2, X1.2
unnamed: R15.2, X1.3
unnamed: R17.1, R18.1, U2.2
unnamed: R17.2, U8.7
unnamed: R29.1, R30.2
unnamed: R30.1, U9.1
unnamed: R32.2, RV1.3
unnamed: R33.1, RV1.1
unnamed: R37.2, U9.5
unnamed: R43.2, U7.6
unnamed: R44.1, U7.1
ONE-WIRE-1: R49.1, U3.8
ONE-WIRE-2: R19.1, U3.22
RESET: C15.2, J1.5, J7.1, R34.2, U3.13
RX: SW1.B, U3.20
SCK: J1.3, R43.1, U3.9
SCL: J5.2, R28.2, U3.18
SDA: J5.3, R25.2, U3.19
TX: D11.1, R44.2, SW1.A, U3.21
USB_N: R14.1, U3.3
USB_P: R15.1, U3.4
VBAT: C19.1, D14.1, Q3.2, R39.1, U5.2, U5.3
VDD: C21.2, D3.1, D4.1, D5.1, D14.2, Q3.1, R29.2, R46.1, U9.4
VUSB: C11.1, D4.2, U3.7, X1.1

File pcb/BOM.md (part):

| Kind                                | Reference                                                             | Value                      | Footprint                                                      | Datasheet                                                                                                                                         | Qty | Mouser Part |
| ----------------------------------- | --------------------------------------------------------------------- | -------------------------- | -------------------------------------------------------------- | ------------------------------------------------------------------------------------------------------------------------------------------------- | --- | - |
| Capacitor                           | C1-C6, C8, C10, C12, C22, C33                                         | 100n                       | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder      | ~                                                                                                                                                 | 11  | https://www.mouser.com/ProductDetail/Wurth-Elektronik/885012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 |
| Capacitor                           | C7, C11, C19-C21, C23, C31                                            | 10u                        | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder      | ~                                                                                                                                                 | 7   | https://www.mouser.com/ProductDetail/KEMET/C0805C106K4PAC?qs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 |
| Capacitor                           | C13, C14                                                              | 22pF                       | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder      | ~                                                                                                                                                 | 2   | https://www.mouser.com/ProductDetail/KEMET/C0805C220K5HACTU?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 |
| Capacitor                           | C13, C14                                                              | 18pF                       | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder      | ~                                                                                                                                                 | 2   | https://www.mouser.com/ProductDetail/KEMET/C0805C180K5HACTU?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 |
| Capacitor                           | C15-C17, C26, C28, C30                                                | 100nF                      | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder      | ~                                                                                                                                                 | 7   | https://www.mouser.com/ProductDetail/Wurth-Elektronik/885012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 |
| Capacitor                           | C18                                            | 1u                        | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder      | ~                                                                                                                                                 | 1   | https://www.mouser.com/ProductDetail/KEMET/C0805C105K4RACTU?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 |
| Capacitor                           | C9, C24, C25                                                          | 22u                        | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder      | ~                                                                                                                                                 | 3   | https://www.mouser.com/ProductDetail/KEMET/C0805C226M9PACTU?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 |
| Capacitor                           | C27, C29                                                              | 10uF                       | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder      | ~                                                                                                                                                 | 2   | https://www.mouser.com/ProductDetail/KEMET/C0805C106K4PAC?qs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 |
| Diode                               | D1, D2                                                                | D                          | Diode_SMD:D_SOD-123                                            | ~                                                                                                                                                 | 2   | https://www.mouser.com/ProductDetail/Diodes-Incorporated/1N4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 |
| Diode Schottky                      | D3-D5, D14                                                            | D_Schottky                 | Diode_SMD:D_SOD-123                                            | ~                                                                                                                                                 | 4   | https://www.mouser.com/ProductDetail/ON-Semiconductor/MBR052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 |
| Diode Bridge                        | D6                                                                    | MB2S                       | Package_TO_SOT_SMD:TO-269AA                                    | http://www.vishay.com/docs/88661/mb2s.pdf                                                                                                         | 1   | https://www.mouser.com/ProductDetail/Vishay-Semiconductors/M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 |
| LED                                 | D7-D13, D17, D18                                                      | LED                        | LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder          | ~                                                                                                                                                 | 9   | https://www.mouser.com/ProductDetail/Wurth-Elektronik/150080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 |
| LED                                 | D15, D16                                                              | RED                        | LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder          | ~                                                                                                                                                 | 2   | https://www.mouser.com/ProductDetail/Wurth-Elektronik/150080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 |
| LED                                 | D19, D20                                                              | TX                         | LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder          | ~                                                                                                                                                 | 2   | https://www.mouser.com/ProductDetail/Wurth-Elektronik/150080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 |
| Display LCD 1602                    | DS1                                                                   | WC1602A                    | Display:WC1602A                                                | http://www.wincomlcd.com/pdf/WC1602A-SFYLYHTC06.pdf                                                                                               | 1   | Not found on Mouser
| Hole                                | H1-H4                                                                 | MountingHole               | MountingHole:MountingHole_3.2mm_M3                             | ~                                                                                                                                                 | 4   | N/A
| SPI Connector                       | J1                                                                    | Conn_02x03_Odd_Even        | Connector:Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical      | ~                                                                                                                                                 | 1   | N/A
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
## Commit log

2020-06-15 migrating pHMeter from bioreactor project
2020-06-15 update pcb
2020-06-15 Created making doc and PCB for revision
2020-06-15 Update 3D for Rotary & BNC
2020-06-17 minor update PCB
2020-06-18 Update 3dmodels
2020-06-25 Add BOM and list on Mouser
2020-07-30 Replace minimum track 8mil -> 16 mil
2020-07-30 created gerber files
2020-07-31 chore: add gitignore
2020-07-31 chore: add label v0.1 on pcb
2020-08-03 Fix MOSFET ZXMS6004 pin mapping
2020-08-04 Update gerber files
2020-08-05 Update BOM list and cart on Mouser
2020-10-15 Update UCAP 100n -> 1u, and update BM + Mouser cart
2020-10-16 Modified some components
2020-10-28 Fix: Changed inductor size (issue #4)
2020-10-30 Fix: renamed value for LEDs
2020-10-30 Fix: Changed BNC connector for pH and conductometer (issue #3)
2021-04-19 update: changes.md
2021-04-21 Update: Doxygen and latex refman
2021-04-26 Update: Migrating blink-code to phMeter
2021-04-27 Update: Doxygen docs
2021-05-09 Updated: New version for board
2021-05-09 Updated: Quick Guide for datasheets
2021-05-11 docs: iBOM.html created
2021-05-11 docs: Readme file to open iBOM.html
2021-05-12 docs: Documentation into PlatformIO was updated
2021-05-12 perf(serial): optimizing code for serial communication
2021-05-13 fix(serial): add responds to not command found.
2021-05-14 refactor(toHex): improve code
2021-05-14 feat(serial): function resetParameters to 0 was created
2021-05-15 fix(serial): 'uc' command updated to see parameters stored in EEPROM.
2021-05-19 perf: Replace folder libraries to lib_deps in platformio.ini. Previous performance: RAM: [==== ] 39.1% (used 1001 bytes from 2560 bytes) Flash: [==== ] 40.2% (used 11518 bytes from 28672 bytes)
    Current performance:
    RAM: [== ] 23.5% (used 601 bytes from 2560 bytes)
    Flash: [== ] 22.5% (used 6460 bytes from 28672 bytes)
2021-06-01 feat: pH and Conductivity adquisition performed (step 1).
2021-07-19 docs: Install guide for Raspberry Pi OS
2021-07-20 docs: Update Raspberry Pi OS installation
2021-07-22 feat: add CAD box and submodule laser-cut-box into CAD folder
2021-07-23 feat: add OpenSCAD for hardware version v0.2
2021-07-23 fix: refactor hardware design
2021-07-23 fix: created holes to one-wire and I2C RJ12 in CAD design
2021-07-29 test: pH titration
2021-07-29 fix: Add I/O space in CAD Design
2021-07-29 build: CAD Design in .svg was created
2021-08-04 fix: relocated LCD in CAD design
2021-08-04 docs: Update README
2021-09-11 updated: previous travel
2021-09-30 docs: new commands for ChiNil RTOS inside logs.md
2021-10-02 fix: ChNil variables
2021-11-26 refactor: change conductometer circuit
2021-11-29 build: pHMeter version 0.2
    Add new circuit for conductometer.
2021-11-29 feat: version 1.0
    Add tags to new version in PCB
2021-11-30 fix: solve CD4060BM and LM2660M fingerprints
    Original fingerprint from manufacturer has an inconsistent desing.
2021-12-01 refactor: Kicad design
2022-02-18 docs: process pH
2022-02-22 docs: pin mapping
2022-04-18 feat: program & upload with USBTinyISP
2022-04-21 docs: To Do
2022-04-21 feat: new branch for I2C
2022-04-22 feat: update PCB to Kicad 6
2022-04-25 fix: symbol libraries in Kicad 6.0
2022-04-25 fix: 3D model libraries in Kicad 6.0
2022-04-26 fix: solved errors in PCB
2022-04-26 test: calibration
2022-04-27 fix: bad name position in PCB and gerber generated
2022-04-27 test: biological testing (water)
2022-04-29 fix: remove additional silkscreen files into the gerber folder
2022-05-20 fix: standard footprint for R and C, BOM updated
2022-05-23 feat: updated BOM
    BOM ready to order in v0.2
2022-05-23 feat: update sch
    Schematic updated with new BOM
2022-05-23 fix: updated iBOM
    Interactive BOM update into pcb folder
2022-06-14 fix: C2 & C4 labels in PCB moved to correct places
2022-06-22 fix: Pin Configuration
2022-06-22 docs: add LCD pin configurations
2022-06-22 style: readme
2022-06-23 feat: pH measurement
2022-06-23 style: monitor flags
2022-06-23 feat: clone bioreactor-platformio
2022-06-30 fix: order code
2022-06-30 fix: LCD display
2022-07-01 feat: created LCDThread
2022-07-01 feat: add sleep header
2022-07-01 feat: LCD Menu
2022-07-01 fix: Interrupts
2022-07-03 docs: lcd.cpp
2022-07-05 feat: adquire Thread and semaphore ADC
2022-07-05 fix: pH reading
2022-07-06 fix: acquire.h->acquireOne
2022-07-06 feat: updated acquire.h
2022-07-06 fix: set Params.h with docs.hackuarium
2022-07-06 feat: StepsThread for pH control
2022-07-07 feat: checking EEPROMLogger.h
2022-07-07 refactor: change priority for Threads
2022-07-07 docs: adding external Flash Memory in pcb->Readme
2022-07-07 feat: updated EEPROMLogger (log Hackuarium )
2022-07-07 fix: EEPROMLogger
2022-07-07 feat: testProbe over testing
2022-07-08 fix: pH reading overflow
2022-07-08 fix: inf loop reading HX711 & set ERRO flag PH
2022-07-08 feat: adding EC files
2022-07-08 test: EC
2022-07-18 docs: updated Pin configuration in pcb/README.md
2022-07-25 feat: new PCB version to 1.1.2
    Schematic:
    - Updated sheets to 1.1.2 version.
    - Change inputs for last OPA in EC sheet.
    - INA- and INA+ set to GND in 24bits sheet for reduce noise.
    - Change /CE connection (TX -> HWB) in Memory and COMM LED.
    - Adding a correct guard in pH sheet.
2022-07-26 fix: pH adquisition
2022-07-26 docs: acquire.cpp
2022-07-26 feat: update /CE pin for flash (TX -> HWB)
2022-07-26 docs: updated README in pcb
2022-07-26 fix: CAD design
2022-07-26 docs: updated iBOM
2022-07-28 fix: CAD deisgn for new version 1.1.2
2022-08-04 fix: CAD design for v1.1.2b
2022-08-11 test: version 1.1.2
    Some bugs are into semphore (ADC or memory access).
2022-08-17 feat: LCD reset & reboot option
2022-08-17 feat: add EC flag in status and enable
2022-08-19 feat: Updated Conductometer sch
    Updated descriptions for CD4060
2022-08-19 fix: pH.scad for v1.1.2-b
2022-08-25 fix: case for v1.1.2-b
2022-09-02 feat: updated BOM information
    Some components are still without MNF and Seller information
2022-09-08 docs: update comments for pH and EC
2022-09-08 fix: reading pH & EC variable to volatile
2022-09-08 refactor: code for lcd menu
2022-09-15 fix: acquire ALL_PARAMETERS
2022-09-16 feat: updated BOM
2022-09-16 refactor: acquire
2023-01-26 feat: adding PID control variable & sync with docs
2023-01-26 fix: increase software version to 1.1.2-c
2023-02-01 feat: update threads

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
