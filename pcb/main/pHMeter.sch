File: pcb/main/pHMeter.sch (KiCad schematic (older format))
At the start: 90 parts, among them J1 Conn_02x03_Odd_Even, J4 AudioJack3_SwitchTR, J5 RJ12, J6 AudioJack3_SwitchTR, J7 SJ, Q1 ZXMS6004, Q2 ZXMS6004, Q3 DMP1045, Q4 ZXMS6004, Q5 ZXMS6004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

Commit message: update pcb
Parts:
- JP3, JP4, JP6, JP7: footprint Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical -> Connector_Molex:Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
- RV1: footprint Potentiometer_THT:Potentiometer_Bourns_3339P_Vertical_HandSoldering -> Potentiometer_THT:Potentiometer_Bourns_3339S_Horizontal
Changed lines of the file:
@@
 F 0 "JP4" V 9679 1153 59  0000 L CNN
 F 1 "alkaline" V 9784 1153 59  0000 L CNN
-F 2 "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" H 9700 1025 50  0001 C CNN
+F 2 "Connector_Molex:Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical" H 9700 1025 50  0001 C CNN
 F 3 "" H 9700 1025 50  0001 C CNN
 	1    9700 1025
@@
 F 0 "JP3" V 9654 2728 59  0000 L CNN
 F 1 "acidic" V 9759 2728 59  0000 L CNN
-F 2 "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" H 9675 2600 50  0001 C CNN
+F 2 "Connector_Molex:Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical" H 9675 2600 50  0001 C CNN
 F 3 "" H 9675 2600 50  0001 C CNN
 	1    9675 2600
@@
 F 0 "RV1" H 6105 8371 50  0000 R CNN
 F 1 "10k" H 6105 8280 50  0000 R CNN
-F 2 "Potentiometer_THT:Potentiometer_Bourns_3339P_Vertical_HandSoldering" H 6175 8325 50  0001 C CNN
+F 2 "Potentiometer_THT:Potentiometer_Bourns_3339S_Horizontal" H 6175 8325 50  0001 C CNN
 F 3 "" H 6175 8325 50  0001 C CNN
 	1    6175 8325
@@
 F 0 "JP6" V 9654 4278 59  0000 L CNN
 F 1 "IO3" V 9759 4278 59  0000 L CNN
-F 2 "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" H 9675 4150 50  0001 C CNN
+F 2 "Connector_Molex:Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical" H 9675 4150 50  0001 C CNN
 F 3 "" H 9675 4150 50  0001 C CNN
 	1    9675 4150
@@
 F 0 "JP7" V 9679 5803 59  0000 L CNN
 F 1 "IO4" V 9784 5803 59  0000 L CNN
-F 2 "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" H 9700 5675 50  0001 C CNN
+F 2 "Connector_Molex:Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical" H 9700 5675 50  0001 C CNN
 F 3 "" H 9700 5675 50  0001 C CNN
 	1    9700 5675
@@
 	6250 9575 6125 9575
 $Comp
-L Bertha_main-eagle-import:GND #?
+L Bertha_main-eagle-import:GND #07
 U 1 1 5FBDA4AD
 P 6200 9925
-F 0 "#?" H 6250 9975 50  0001 C CNN
+F 0 "#07" H 6250 9975 50  0001 C CNN
 F 1 "GND" H 6303 9963 42  0000 L CNN
 F 2 "" H 6200 9925 50  0001 C CNN

Commit message: Created making doc and PCB for revision
Parts:
- JP5: footprint Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical -> Connector_Molex:Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
Connections:
- net A3: no longer C33.1, R38.2, R45.1
- net A4: now also C33.1, R38.2, R45.1
- net D11: no longer SW1.S1
- net D7: now also SW1.S1
Other:
- moved on the sheet: H1, H2, H3, H4
Changed lines of the file:
@@
 	7375 4400 7375 4500
 Text GLabel 3500 4000 2    50   Input ~ 0
-A5
+A0
 Text GLabel 3500 4100 2    50   Input ~ 0
-D7
+A1
 Text GLabel 2025 3975 0    50   Input ~ 0
 B+
@@
 	2625 1775 2625 1825
 $Comp
-L Bertha_main-eagle-import:JP1E JP5
-U 1 1 5EFAFB88
-P 3275 1775
-F 0 "JP5" V 3254 1903 59  0000 L CNN
-F 1 "Bat" V 3359 1903 59  0000 L CNN
-F 2 "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" H 3275 1775 50  0001 C CNN
-F 3 "" H 3275 1775 50  0001 C CNN
-	1    3275 1775
-	0    1    1    0
-$EndComp
-$Comp
 L Bertha_main-eagle-import:GND #U0108
 U 1 1 5EFC5A9A
@@
 	3850 1900 3850 2000
 Text GLabel 4325 1900 2    50   Input ~ 0
-A3
+A4
 Wire Wire Line
 	4325 1900 4175 1900
@@
 L Mechanical:MountingHole H1
 U 1 1 5F726A2E
-P 800 8750
-F 0 "H1" H 900 8796 50  0000 L CNN
-F 1 "MountingHole" H 900 8705 50  0000 L CNN
-F 2 "MountingHole:MountingHole_3.2mm_M3" H 800 8750 50  0001 C CNN
-F 3 "~" H 800 8750 50  0001 C CNN
-	1    800  8750
+P 700 8750
+F 0 "H1" H 800 8796 50  0000 L CNN
+F 1 "MountingHole" H 800 8705 50  0000 L CNN
+F 2 "MountingHole:MountingHole_3.2mm_M3" H 700 8750 50  0001 C CNN
+F 3 "~" H 700 8750 50  0001 C CNN
+	1    700  8750
 	1    0    0    -1
 $EndComp
@@
 L Mechanical:MountingHole H3
 U 1 1 5F72BE62
-P 1700 8725
-F 0 "H3" H 1800 8771 50  0000 L CNN
-F 1 "MountingHole" H 1800 8680 50  0000 L CNN
-F 2 "MountingHole:MountingHole_3.2mm_M3" H 1700 8725 50  0001 C CNN
-F 3 "~" H 1700 8725 50  0001 C CNN
-	1    1700 8725
+P 1500 8750
+F 0 "H3" H 1600 8796 50  0000 L CNN
+F 1 "MountingHole" H 1600 8705 50  0000 L CNN
+F 2 "MountingHole:MountingHole_3.2mm_M3" H 1500 8750 50  0001 C CNN
+F 3 "~" H 1500 8750 50  0001 C CNN
+	1    1500 8750
 	1    0    0    -1
 $EndComp
@@
 L Mechanical:MountingHole H2
 U 1 1 5F72C0AF
-P 825 9175
-F 0 "H2" H 925 9221 50  0000 L CNN
-F 1 "MountingHole" H 925 9130 50  0000 L CNN
-F 2 "MountingHole:MountingHole_3.2mm_M3" H 825 9175 50  0001 C CNN
-F 3 "~" H 825 9175 50  0001 C CNN
-	1    825  9175
+P 700 9075
+F 0 "H2" H 800 9121 50  0000 L CNN
+F 1 "MountingHole" H 800 9030 50  0000 L CNN
+F 2 "MountingHole:MountingHole_3.2mm_M3" H 700 9075 50  0001 C CNN
+F 3 "~" H 700 9075 50  0001 C CNN
+	1    700  9075
 	1    0    0    -1
 $EndComp
@@
 L Mechanical:MountingHole H4
 U 1 1 5F72C2E2
-P 1700 9175
-F 0 "H4" H 1800 9221 50  0000 L CNN
-F 1 "MountingHole" H 1800 9130 50  0000 L CNN
-F 2 "MountingHole:MountingHole_3.2mm_M3" H 1700 9175 50  0001 C CNN
-F 3 "~" H 1700 9175 50  0001 C CNN
-	1    1700 9175
+P 1500 9075
+F 0 "H4" H 1600 9121 50  0000 L CNN
+F 1 "MountingHole" H 1600 9030 50  0000 L CNN
+F 2 "MountingHole:MountingHole_3.2mm_M3" H 1500 9075 50  0001 C CNN
+F 3 "~" H 1500 9075 50  0001 C CNN
+	1    1500 9075
 	1    0    0    -1
 $EndComp
@@
 	5425 9575 5525 9575
 Text GLabel 6250 9575 2    50   Input ~ 0
-D11
+D7
 Wire Wire Line
 	6250 9575 6125 9575
@@
 Wire Notes Line
 	475  7075 16050 7075
+$Comp
+L Bertha_main-eagle-import:JP1E JP5
+U 1 1 5EFAFB88
+P 3275 1775
+F 0 "JP5" V 3254 1903 59  0000 L CNN
+F 1 "Bat" V 3359 1903 59  0000 L CNN
+F 2 "Connector_Molex:Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical" H 3275 1775 50  0001 C CNN
+F 3 "" H 3275 1775 50  0001 C CNN
+	1    3275 1775
+	0    1    1    0
+$EndComp
 $EndSCHEMATC

Commit message: Update UCAP 100n -> 1u, and update BM + Mouser cart
Parts:
- C18: value 100nF -> 1uF
Changed lines of the file:
@@
 AR Path="/5EED4C28" Ref="C18"  Part="1"
 F 0 "C18" V 11925 3125 50  0000 C CNN
-F 1 "100nF" V 12025 3125 50  0000 C CNN
+F 1 "1uF" V 12025 3125 50  0000 C CNN
 F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 12013 2800 50  0001 C CNN
 F 3 "~" H 11975 2950 50  0001 C CNN

Commit message: Modified some components
Parts:
- C13, C14: value 22pF -> 18pF
- R20, R21, R23, R24: value 10k -> 1k
Changed lines of the file:
@@
 P 7925 3850
 F 0 "R24" H 7995 3896 50  0000 L CNN
-F 1 "10k" H 7995 3805 50  0000 L CNN
+F 1 "1k" H 7995 3805 50  0000 L CNN
 F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" V 7855 3850 50  0001 C CNN
 F 3 "~" H 7925 3850 50  0001 C CNN
@@
 P 7375 3850
 F 0 "R23" H 7445 3896 50  0000 L CNN
-F 1 "10k" H 7445 3805 50  0000 L CNN
+F 1 "1k" H 7445 3805 50  0000 L CNN
 F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" V 7305 3850 50  0001 C CNN
 F 3 "~" H 7375 3850 50  0001 C CNN
@@
 P 7100 3850
 F 0 "R21" H 7170 3896 50  0000 L CNN
-F 1 "10k" H 7170 3805 50  0000 L CNN
+F 1 "1k" H 7170 3805 50  0000 L CNN
 F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" V 7030 3850 50  0001 C CNN
 F 3 "~" H 7100 3850 50  0001 C CNN
@@
 P 6825 3850
 F 0 "R20" H 6895 3896 50  0000 L CNN
-F 1 "10k" H 6895 3805 50  0000 L CNN
+F 1 "1k" H 6895 3805 50  0000 L CNN
 F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" V 6755 3850 50  0001 C CNN
 F 3 "~" H 6825 3850 50  0001 C CNN
@@
 AR Path="/5EED4C0F" Ref="C13"  Part="1"
 F 0 "C13" V 11275 3400 50  0000 C CNN
-F 1 "22pF" V 11350 3400 50  0000 C CNN
+F 1 "18pF" V 11350 3400 50  0000 C CNN
 F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 11513 3250 50  0001 C CNN
 F 3 "~" H 11475 3400 50  0001 C CNN
@@
 AR Path="/5EED4C15" Ref="C14"  Part="1"
 F 0 "C14" V 11675 3600 50  0000 C CNN
-F 1 "22pF" V 11600 3625 50  0000 C CNN
+F 1 "18pF" V 11600 3625 50  0000 C CNN
 F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 11513 3450 50  0001 C CNN
 F 3 "~" H 11475 3600 50  0001 C CNN

Commit message: Fix: renamed value for LEDs
Parts:
- C11, C20, C21, C23, C7: Description (none) -> Multilayer Ceramic Capacitors MLCC - SMD/SMT 16V 10uF X5R 0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; MFN (none) -> Samsung Electro-Mechanics; MFP (none) -> CL21A106KOQNNNG; S1PL (none) -> https://www.mouser.com/ProductDetail/Samsung-Electro-Mechan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; S1PN (none) -> 187-CL21A106KOQNNNG
- C13, C14: value 18pF -> 18p; Description (none) -> Multilayer Ceramic Capacitors MLCC - SMD/SMT 50V 18pF X8R 0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; MFN (none) -> KEMET; MFP (none) -> C0805C180K5HACTU; S1PL (none) -> https://www.mouser.com/ProductDetail/KEMET/C0805C180K5HACTU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; S1PN (none) -> 80-C0805C180K5HACTU
- C15, C16, C17: value 100nF -> 100n; Description (none) -> Multilayer Ceramic Capacitors MLCC - SMD/SMT WCAP-CSGP 0.1u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; MFN (none) -> Wurth Elektronik; MFP (none) -> 885012207072; S1PL (none) -> https://www.mouser.com/ProductDetail/Wurth-Elektronik/88501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; S1PN (none) -> 710-885012207072
- C18: value 1uF -> 1u; Description (none) -> Multilayer Ceramic Capacitors MLCC - SMD/SMT 50V .1uF X7R 0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; MFN (none) -> AVX; MFP (none) -> 08055C104KAT2A; S1PL (none) -> https://www.mouser.com/ProductDetail/AVX/08055C104KAT2A?qs=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; S1PN (none) -> 581-08055C104K
- C33, C6: Description (none) -> Multilayer Ceramic Capacitors MLCC - SMD/SMT WCAP-CSGP 0.1u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; MFN (none) -> Wurth Elektronik; MFP (none) -> 885012207072; S1PL (none) -> https://www.mouser.com/ProductDetail/Wurth-Elektronik/88501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; S1PN (none) -> 710-885012207072
- D10, D11, D9: value LED -> YELLOW
- D12, D13, D17, D18: value LED -> BLUE
- D14, D3, D4, D5: value D_Schottky -> MBR0520LT1G; Description (none) -> Schottky Diodes & Rectifiers 0.5A 20V; MFN (none) -> ON Semiconductor; MFP (none) -> MBR0520LT1G; S1PL (none) -> https://www.mouser.com/ProductDetail/ON-Semiconductor/MBR05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; S1PN (none) -> 863-MBR0520LT1G
- D19, D20: value TX -> YELLOW
- D7, D8: value LED -> GREEN
- RV1: footprint Potentiometer_THT:Potentiometer_Bourns_3339S_Horizontal -> Potentiometer_THT:Potentiometer_Bourns_3339P_Vertical_HandSoldering
Connections:
- net at RV1.1: now also R33.1; no longer R32.2
- net at RV1.3: now also R32.2; no longer R33.1
Other:
- moved on the sheet: D10, D11, D8, D9, R20, R21, R23, R24
