File: pcb/main/Memory.kicad_sch (KiCad schematic)
At the start: 5 parts

Commit message: fix: symbol libraries in Kicad 6.0
Parts:
- C31: value (none) -> 10u; footprint (none) -> Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; symbol pHMeter-rescue:C-Device -> Device:C
- R42, R43, R44: value (none) -> 1k; footprint (none) -> Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; symbol pHMeter-rescue:R-Device -> Device:R
- U7: value (none) -> SST26VF064B; footprint (none) -> Package_SO:SOIJ-8_5.3x5.3mm_P1.27mm
Connections:
- net 3.3V: now also C31.1, R42.2
- net CE: now also R44.2
- net GND: now also C31.2
- net MOSI: now also R42.1
- net SCK: now also R43.1
- net at U7.1 (~{CE}): now also R44.1
- net at U7.6 (SCK): now also R43.2
Changed lines of the file:
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@@
     (effects (font (size 1.27 1.27)) (justify right))
   )
-  (symbol (lib_id "pHMeter-rescue:R-Device") (at 116.84 59.055 270) (unit 1)
+  (symbol (lib_id "Device:R") (at 116.84 59.055 270) (unit 1)
     (in_bom yes) (on_board yes)
     (property "Reference" "R44" (id 0) (at 112.395 57.785 90))
-    (property "Value" "" (id 1) (at 120.65 60.325 90))
-    (property "Footprint" "" (id 2) (at 116.84 57.277 90)
+    (property "Value" "1k" (id 1) (at 120.65 60.325 90))
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 116.84 57.277 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (pin "1")
+    (pin "2")
   )
-  (symbol (lib_id "pHMeter-rescue:R-Device") (at 116.84 56.515 90) (mirror x) (unit 1)
+  (symbol (lib_id "Device:R") (at 116.84 56.515 90) (mirror x) (unit 1)
     (in_bom yes) (on_board yes)
     (property "Reference" "R43" (id 0) (at 112.395 55.245 90))
-    (property "Value" "" (id 1) (at 120.65 57.785 90))
-    (property "Footprint" "" (id 2) (at 116.84 54.737 90)
+    (property "Value" "1k" (id 1) (at 120.65 57.785 90))
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 116.84 54.737 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (pin "1")
+    (pin "2")
   )
-  (symbol (lib_id "pHMeter-rescue:R-Device") (at 102.235 48.895 0) (mirror x) (unit 1)
+  (symbol (lib_id "Device:R") (at 102.235 48.895 0) (mirror x) (unit 1)
     (in_bom yes) (on_board yes)
     (property "Reference" "R42" (id 0) (at 100.457 47.7266 0)
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Value" "" (id 1) (at 100.457 50.038 0)
+    (property "Value" "1k" (id 1) (at 100.457 50.038 0)
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Footprint" "" (id 2) (at 100.457 48.895 90)
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 100.457 48.895 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (pin "1")
+    (pin "2")
   )
-  (symbol (lib_id "pHMeter-rescue:C-Device") (at 112.395 38.735 0) (unit 1)
+  (symbol (lib_id "Device:C") (at 112.395 38.735 0) (unit 1)
     (in_bom yes) (on_board yes)
     (property "Reference" "C31" (id 0) (at 115.316 37.5666 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (id 1) (at 115.316 39.878 0)
+    (property "Value" "10u" (id 1) (at 115.316 39.878 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (id 2) (at 113.3602 42.545 0)
+    (property "Footprint" "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 113.3602 42.545 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (pin "1")
+    (pin "2")
   )
   (symbol (lib_id "bioreactor:SST26VF064B") (at 133.35 59.055 0) (unit 1)
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (id 1) (at 144.6276 60.198 0)
+    (property "Value" "SST26VF064B" (id 1) (at 144.6276 60.198 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (id 2) (at 133.35 76.835 0)
+    (property "Footprint" "Package_SO:SOIJ-8_5.3x5.3mm_P1.27mm" (id 2) (at 133.35 76.835 0)
       (effects (font (size 1.27 1.27)) hide)
     )

Commit message: fix: standard footprint for R and C, BOM updated
Parts:
- C31: value 10u -> (none); footprint Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder -> (none); MFN Samsung Electro-Mechanics -> Wurth Elektronik; MFP CL21A106KOQNNNG -> 885012207072; S1PL https://www.mouser.com/ProductDetail/Samsung-Electro-Mechan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 -> https://www.mouser.com/ProductDetail/Wurth-Elektronik/88501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; S1PN 187-CL21A106KOQNNNG -> 710-885012207072
- R42, R43, R44: value 1k -> (none); footprint Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder -> (none)
- U7: value SST26VF064B -> (none); footprint Package_SO:SOIJ-8_5.3x5.3mm_P1.27mm -> (none)
Changed lines of the file:
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@@
     (in_bom yes) (on_board yes)
     (property "Reference" "R44" (id 0) (at 112.395 57.785 90))
-    (property "Value" "1k" (id 1) (at 120.65 60.325 90))
-    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 116.84 57.277 90)
+    (property "Value" "" (id 1) (at 120.65 60.325 90))
+    (property "Footprint" "" (id 2) (at 116.84 57.277 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (in_bom yes) (on_board yes)
     (property "Reference" "R43" (id 0) (at 112.395 55.245 90))
-    (property "Value" "1k" (id 1) (at 120.65 57.785 90))
-    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 116.84 54.737 90)
+    (property "Value" "" (id 1) (at 120.65 57.785 90))
+    (property "Footprint" "" (id 2) (at 116.84 54.737 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Value" "1k" (id 1) (at 100.457 50.038 0)
+    (property "Value" "" (id 1) (at 100.457 50.038 0)
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 100.457 48.895 90)
+    (property "Footprint" "" (id 2) (at 100.457 48.895 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "10u" (id 1) (at 115.316 39.878 0)
+    (property "Value" "" (id 1) (at 115.316 39.878 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 113.3602 42.545 0)
+    (property "Footprint" "" (id 2) (at 113.3602 42.545 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.mouser.com/datasheet/2/585/MLCC-1837944.pdf" (id 3) (at 112.395 38.735 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/445/885012207072-1727745.pdf" (id 3) (at 112.395 38.735 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Description" "Multilayer Ceramic Capacitors MLCC - SMD/SMT 16V 10uF X5R 0805 10%" (id 4) (at 112.395 38.735 0)
+    (property "Description" "Multilayer Ceramic Capacitors MLCC - SMD/SMT WCAP-CSGP 0.1uF 0805 10% 25V MLCC " (id 4) (at 112.395 38.735 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "MFN" "Samsung Electro-Mechanics " (id 5) (at 112.395 38.735 0)
+    (property "MFN" "Wurth Elektronik " (id 5) (at 112.395 38.735 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "MFP" "CL21A106KOQNNNG " (id 6) (at 112.395 38.735 0)
+    (property "MFP" "885012207072" (id 6) (at 112.395 38.735 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "S1PL" "https://www.mouser.com/ProductDetail/Samsung-Electro-Mechanics/CL21A106KOQNNNG?qs=hqM3L16%252BxlcMWI7QbqH0LA%3D%3D" (id 7) (at 112.395 38.735 0)
+    (property "S1PL" "https://www.mouser.com/ProductDetail/Wurth-Elektronik/885012207072?qs=0KOYDY2FL28rQMV4504TxA%3D%3D" (id 7) (at 112.395 38.735 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "S1PN" " 187-CL21A106KOQNNNG " (id 8) (at 112.395 38.735 0)
+    (property "S1PN" "710-885012207072 " (id 8) (at 112.395 38.735 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "SST26VF064B" (id 1) (at 144.6276 60.198 0)
+    (property "Value" "" (id 1) (at 144.6276 60.198 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Package_SO:SOIJ-8_5.3x5.3mm_P1.27mm" (id 2) (at 133.35 76.835 0)
+    (property "Footprint" "" (id 2) (at 133.35 76.835 0)
       (effects (font (size 1.27 1.27)) hide)
     )

Commit message: feat: updated BOM
BOM ready to order in v0.2
Parts:
- C31: value (none) -> 10u; footprint (none) -> Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFN Wurth Elektronik -> Samsung Electro-Mechanics; MFP 885012207072 -> CL21A106KOQNNNG; S1PL https://www.mouser.com/ProductDetail/Wurth-Elektronik/88501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 -> https://www.mouser.com/ProductDetail/Samsung-Electro-Mechan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; S1PN 710-885012207072 -> 187-CL21A106KOQNNNG
- R42, R43, R44: value (none) -> 1k; footprint (none) -> Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
- U7: value (none) -> SST26VF064B; footprint (none) -> Package_SO:SOIJ-8_5.3x5.3mm_P1.27mm
Changed lines of the file:
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@@
     (in_bom yes) (on_board yes)
     (property "Reference" "R44" (id 0) (at 112.395 57.785 90))
-    (property "Value" "" (id 1) (at 120.65 60.325 90))
-    (property "Footprint" "" (id 2) (at 116.84 57.277 90)
+    (property "Value" "1k" (id 1) (at 120.65 60.325 90))
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 116.84 57.277 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (in_bom yes) (on_board yes)
     (property "Reference" "R43" (id 0) (at 112.395 55.245 90))
-    (property "Value" "" (id 1) (at 120.65 57.785 90))
-    (property "Footprint" "" (id 2) (at 116.84 54.737 90)
+    (property "Value" "1k" (id 1) (at 120.65 57.785 90))
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 116.84 54.737 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Value" "" (id 1) (at 100.457 50.038 0)
+    (property "Value" "1k" (id 1) (at 100.457 50.038 0)
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Footprint" "" (id 2) (at 100.457 48.895 90)
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 100.457 48.895 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (id 1) (at 115.316 39.878 0)
+    (property "Value" "10u" (id 1) (at 115.316 39.878 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (id 2) (at 113.3602 42.545 0)
+    (property "Footprint" "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder" (id 2) (at 113.3602 42.545 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.mouser.com/datasheet/2/445/885012207072-1727745.pdf" (id 3) (at 112.395 38.735 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/585/MLCC-1837944.pdf" (id 3) (at 112.395 38.735 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Description" "Multilayer Ceramic Capacitors MLCC - SMD/SMT WCAP-CSGP 0.1uF 0805 10% 25V MLCC " (id 4) (at 112.395 38.735 0)
+    (property "Description" "Capacitores cerámicos de capas múltiples (MLCC) - SMD/SMT 10uF+/-10% 16V X5R 2 0805 " (id 4) (at 112.395 38.735 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "MFN" "Wurth Elektronik " (id 5) (at 112.395 38.735 0)
+    (property "MFN" "Samsung Electro-Mechanics " (id 5) (at 112.395 38.735 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "MFP" "885012207072" (id 6) (at 112.395 38.735 0)
+    (property "MFP" "CL21A106KOQNNNG " (id 6) (at 112.395 38.735 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "S1PL" "https://www.mouser.com/ProductDetail/Wurth-Elektronik/885012207072?qs=0KOYDY2FL28rQMV4504TxA%3D%3D" (id 7) (at 112.395 38.735 0)
+    (property "S1PL" "https://www.mouser.com/ProductDetail/Samsung-Electro-Mechanics/CL21A106KOQNNNG?qs=hqM3L16%252BxlcMWI7QbqH0LA%3D%3D" (id 7) (at 112.395 38.735 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "S1PN" "710-885012207072 " (id 8) (at 112.395 38.735 0)
+    (property "S1PN" "187-CL21A106KOQNNNG " (id 8) (at 112.395 38.735 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (id 1) (at 144.6276 60.198 0)
+    (property "Value" "SST26VF064B" (id 1) (at 144.6276 60.198 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (id 2) (at 133.35 76.835 0)
+    (property "Footprint" "Package_SO:SOIJ-8_5.3x5.3mm_P1.27mm" (id 2) (at 133.35 76.835 0)
       (effects (font (size 1.27 1.27)) hide)
     )

Commit message: feat: updated BOM information
Some components are still without MNF and Seller information
Parts:
- C31: value 10u -> (none); footprint Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder -> (none)
- R42, R43, R44: value 1k -> (none); footprint Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder -> (none); MFN (none) -> KOA Speer; MFP (none) -> RK73H2ATTD1001F; S1PL (none) -> https://www.mouser.com/ProductDetail/KOA-Speer/RK73H2ATTD10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; S1PN (none) -> 660-RK73H2ATTD1001F
- U7: value SST26VF064B -> (none); footprint Package_SO:SOIJ-8_5.3x5.3mm_P1.27mm -> (none)
Changed lines of the file:
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@@
     (in_bom yes) (on_board yes)
     (property "Reference" "R44" (id 0) (at 112.395 57.785 90))
-    (property "Value" "1k" (id 1) (at 120.65 60.325 90))
-    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 116.84 57.277 90)
+    (property "Value" "" (id 1) (at 120.65 60.325 90))
+    (property "Footprint" "" (id 2) (at 116.84 57.277 90)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (id 3) (at 116.84 59.055 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/219/RK73H-1825326.pdf" (id 3) (at 116.84 59.055 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Thick Film Resistors - SMD 1/4watts 1Kohms 1% " (id 4) (at 116.84 59.055 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "KOA Speer " (id 5) (at 116.84 59.055 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "RK73H2ATTD1001F " (id 6) (at 116.84 59.055 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/KOA-Speer/RK73H2ATTD1001F?qs=sGAEpiMZZMtlubZbdhIBIHMXi0pPDQ96wRIUy6HwZNc%3D" (id 7) (at 116.84 59.055 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" "660-RK73H2ATTD1001F " (id 8) (at 116.84 59.055 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (in_bom yes) (on_board yes)
     (property "Reference" "R43" (id 0) (at 112.395 55.245 90))
-    (property "Value" "1k" (id 1) (at 120.65 57.785 90))
-    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 116.84 54.737 90)
+    (property "Value" "" (id 1) (at 120.65 57.785 90))
+    (property "Footprint" "" (id 2) (at 116.84 54.737 90)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (id 3) (at 116.84 56.515 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/219/RK73H-1825326.pdf" (id 3) (at 116.84 56.515 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Thick Film Resistors - SMD 1/4watts 1Kohms 1% " (id 4) (at 116.84 56.515 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "KOA Speer " (id 5) (at 116.84 56.515 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "RK73H2ATTD1001F " (id 6) (at 116.84 56.515 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/KOA-Speer/RK73H2ATTD1001F?qs=sGAEpiMZZMtlubZbdhIBIHMXi0pPDQ96wRIUy6HwZNc%3D" (id 7) (at 116.84 56.515 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" "660-RK73H2ATTD1001F " (id 8) (at 116.84 56.515 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Value" "1k" (id 1) (at 100.457 50.038 0)
+    (property "Value" "" (id 1) (at 100.457 50.038 0)
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 100.457 48.895 90)
+    (property "Footprint" "" (id 2) (at 100.457 48.895 90)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (id 3) (at 102.235 48.895 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/219/RK73H-1825326.pdf" (id 3) (at 102.235 48.895 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Thick Film Resistors - SMD 1/4watts 1Kohms 1% " (id 4) (at 102.235 48.895 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "KOA Speer " (id 5) (at 102.235 48.895 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "RK73H2ATTD1001F " (id 6) (at 102.235 48.895 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/KOA-Speer/RK73H2ATTD1001F?qs=sGAEpiMZZMtlubZbdhIBIHMXi0pPDQ96wRIUy6HwZNc%3D" (id 7) (at 102.235 48.895 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" "660-RK73H2ATTD1001F " (id 8) (at 102.235 48.895 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "10u" (id 1) (at 115.316 39.878 0)
+    (property "Value" "" (id 1) (at 115.316 39.878 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder" (id 2) (at 113.3602 42.545 0)
+    (property "Footprint" "" (id 2) (at 113.3602 42.545 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "SST26VF064B" (id 1) (at 144.6276 60.198 0)
+    (property "Value" "" (id 1) (at 144.6276 60.198 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Package_SO:SOIJ-8_5.3x5.3mm_P1.27mm" (id 2) (at 133.35 76.835 0)
+    (property "Footprint" "" (id 2) (at 133.35 76.835 0)
       (effects (font (size 1.27 1.27)) hide)
     )
